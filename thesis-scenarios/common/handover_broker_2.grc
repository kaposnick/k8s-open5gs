options:
  parameters:
    generate_options: qt_gui
    id: intra_enb
    output_language: python
    title: Intra Handover Flowgraph
  states: {}

blocks:
- name: cell_gain0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ue1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ue1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2002
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_ue1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_ue1_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2003
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_1, '0', zeromq_rep_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_ue1, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_ue1_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_1, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_1, '1']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_ue1, '0', blocks_throttle_0, '0']
- [zeromq_req_source_ue1_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
