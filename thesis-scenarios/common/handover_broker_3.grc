options:
  parameters:
    generate_options: qt_gui
    id: intra_enb
    output_language: python
    title: Intra Handover Flowgraph
  states: {}

blocks:
- name: cell_gain0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: cell_gain1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: zeromq_rep_sink_ue1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ue1_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2301
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ue1_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2151
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ue1_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2150
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2200
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2300
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_req_source_0, '0', zeromq_rep_sink_ue1_0, '0']
- [zeromq_req_source_0_0, '0', zeromq_rep_sink_ue1_0_0, '0']
- [zeromq_req_source_0_0_0, '0', zeromq_rep_sink_ue1_0_1, '0']
- [zeromq_req_source_0_0_0_0, '0', zeromq_rep_sink_ue1_0_0_0, '0']

metadata:
  file_format: 1
